# Keil uVision project Mini DSO.uvproj, settings and files
target Mini_DSO (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Mini_DSO +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: STARTUP.A51 main.c delay.c adc_stc8.c settings.c ssd1306.c eeprom.c chart.c global.c global.h bmp.h chart.h config_stc.h delay.h eeprom.h settings.h ssd1306.h ssd1306font.h adc_stc8.h
