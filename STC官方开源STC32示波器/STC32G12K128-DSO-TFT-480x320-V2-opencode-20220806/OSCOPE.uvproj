# Keil uVision project OSCOPE.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: OSCOPE +hex
  group Source Group 1
    ./: EEPROM.c TFT480x320-V2.c OSCOPE-V2-8bit.c
